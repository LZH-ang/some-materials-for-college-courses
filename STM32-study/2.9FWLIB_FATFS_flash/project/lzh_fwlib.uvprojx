# Keil uVision project lzh_fwlib.uvprojx, settings and files
target USART_RGB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lzh_fwlib +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\libraries\CMSIS;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\user\LED;..\user\USART;..\user\FLASH;..\user\FATFS\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../user/: main.c stm32f10x_it.c
    ../user/LED/: bsp_led.c
    ../user/USART/: bsp_usart.c
    ../user/FLASH/: bsp_spi_flash.c
  group FATFS
    ../user/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group DOC
    ../doc/: readme.txt
